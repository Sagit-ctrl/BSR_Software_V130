# IAR project SubGHz_Phy_PingPong.ewp, settings and files
configuration cmwx1zzabz_0xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CZ ST STM32L072CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L072xx; CMWX1ZZABZ0XX; DEVICE_TYPE_STATION
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/B-L072Z-LRWAN1; ../../../../../../Drivers/BSP/CMWX1ZZABZ_0xx; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1276; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_app\Inc; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_change\Inc; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_device\Inc; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_generate\Inc; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_util\Inc; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_app\Src; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_change\Src; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_device\Src; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_generate\Src; C:\Users\Sagit\Desktop\BSR_Software_V110\Usercode\user_util\Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SubGHz_Phy_PingPong.bin
  ILINK.IlinkOutputFile: cmwx1zzabz_0xx.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/App
    ../SubGHz_Phy/App/: app_subghz_phy.c subghz_phy_app.c
  group Application/Core
    ../Core/Src/: dma.c main.c rtc.c stm32l0xx_hal_msp.c stm32l0xx_it.c sys_app.c sys_debug.c usart_if.c
  group Application/EWARM
    ./: startup_stm32l072xx.s
  group Application/Target
    ../SubGHz_Phy/Target/: b_l072z_lrwan1_bus.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L072Z-LRWAN1
    ../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Drivers/BSP/CMWX1ZZABZ_0xx
    ../../../../../../Drivers/BSP/CMWX1ZZABZ_0xx/: cmwx1zzabz_0xx.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1276/: sx1276.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
